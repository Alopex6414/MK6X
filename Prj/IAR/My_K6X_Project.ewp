# IAR project My_K6X_Project.ewp, settings and files
configuration MK66FN2M0 (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK66F18; MK66FN2M0
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\Inc; ..\..\Drive\Inc; ..\..\File; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB\Inc; ..\..\Start\MK6X
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: My_K6X_Project.hex
  ILINK.IlinkOutputFile: My_K6X_Project.out
  ILINK.IlinkIcfFile: config files\MK66FN2M0_FLASH.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK66FX1M0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK66F18; MK66FX1M0
  ILINK.IlinkIcfFile: config files\MK66FX1M0_FLASH.icf
configuration MK64FN1M0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK64F12; MK64FN1M0
  ILINK.IlinkIcfFile: config files\MK64FN1M0_FLASH.icf
configuration MK64FX512 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FX512xxx12 NXP MK64FX512xxx12
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK64F12; MK64FX512
  ILINK.IlinkIcfFile: config files\MK64FX512_FLASH.icf
  group App
    ../../App/Src/: App_Init.c Main.c MK6X_Conf.c MK6X_It.c
  group Board
    ../../Board/Src/: MAPS_Dock_I2C.c MAPS_Dock_Key.c MAPS_Dock_LCM.c MAPS_Dock_LED.c MAPS_Dock_Rocker.c MAPS_Dock_SDCard.c MAPS_Dock_W25Q80.c MAPS_LCD.c
  group Chip
    ../../Chip/Inc/: Common.h Include.h
    ../../Chip/Src/: MK6X_ADC.c MK6X_CAN.c MK6X_DAC.c MK6X_DELAY.c MK6X_DMA.c MK6X_DWT.c MK6X_FLASH.c MK6X_FLEXBUS.c MK6X_FTM.c MK6X_GPIO.c MK6X_I2C.c MK6X_I2S.c MK6X_LPTMR.c MK6X_MCG.c MK6X_PDB.c MK6X_PIT.c MK6X_PORT.c MK6X_RTC.c MK6X_SDHC.c MK6X_SPI.c MK6X_SysTick.c MK6X_UART.c MK6X_USB.c MK6X_WDOG.c
  group Drive
    ../../Drive/Src/: Drive_Camera.c Drive_CCD.c Drive_MPU6050.c Drive_Oled.c Drive_Oled_Lib.c Drive_RTC_Count.c
  group Inc
    ../../App/Inc/: App_Init.h Main.h MK6X_Conf.h MK6X_It.h
    ../../Drive/Inc/: Drive_Camera.h Drive_CCD.h Drive_MPU6050.h Drive_Oled.h Drive_RTC_Count.h
    ../../Board/Inc/: MAPS_Dock_I2C.h MAPS_Dock_Key.h MAPS_Dock_LCM.h MAPS_Dock_LCM_Lib.h MAPS_Dock_LED.h MAPS_Dock_Rocker.h MAPS_Dock_SDCard.h MAPS_Dock_W25Q80.h MAPS_LCD.h MAPS_LCD_Font.h MAPS_LCD_Pic.h
    ../../Start/MK6X/: MK64F12.h MK66F18.h MK6X_Misc.h MK6X_SystemInit.h MK6X_Vectors.h
    ../../Chip/Inc/: MK6X_ADC.h MK6X_CAN.h MK6X_DAC.h MK6X_DELAY.h MK6X_DMA.h MK6X_DWT.h MK6X_FLASH.h MK6X_FLEXBUS.h MK6X_FTM.h MK6X_GPIO.h MK6X_GPIO_CFG.h MK6X_I2C.h MK6X_I2S.h MK6X_LPTMR.h MK6X_MCG.h MK6X_PDB.h MK6X_PIT.h MK6X_PORT.h MK6X_PORT_CFG.h MK6X_RTC.h MK6X_SDHC.h MK6X_SPI.h MK6X_SysTick.h MK6X_UART.h MK6X_USB.h MK6X_WDOG.h
  group Lib/CMSIS
    ../../Lib/CMSIS/Inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group Lib/FATFS
    ../../Lib/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h readme.txt
  group Lib/USB
    ../../Lib/USB/Inc/: FSL_Types.h USB.h USB_CDC.h USB_Desc.h
    ../../Lib/USB/Src/: USB.c USB_CDC.c
  group Prj
    config files/: MK64FN1M0_FLASH.icf MK64FN1M0_RAM.icf MK64FX512_FLASH.icf MK64FX512_RAM.icf MK66FN2M0_FLASH.icf MK66FN2M0_RAM.icf MK66FX1M0_FLASH.icf MK66FX1M0_RAM.icf
  group Start
    ../../Start/MK6X/: MK6X_Misc.c MK6X_StartUp.s MK6X_SystemInit.c MK6X_Vectors.c
