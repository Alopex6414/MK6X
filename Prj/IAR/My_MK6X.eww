<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\My_K6X_Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


